# Keil uVision project XMC4800-F144.uvprojx, settings and files
target XMC4800-F144x2048 (6160000::V6.16::ARMCLANG)
  device: XMC4800-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XMC4800-F144
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c include: ..\..\source\platform\XMC4800-F144+DAVE\GENERATED;..\..\source\platform\XMC4800-F144+DAVE;..\..\source\common;..\..\source\common\vercion\default;.\..\..\..\..\reference\robosdpp-ref;.\..\..\..\..\reference\robosdpp-ref\core\platform\keil+cpp6
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group app/common
    ../../source/common/: board_common.hpp zppm.cpp zppm.hpp
  group app/common/vercion/default
    ../../source/common/vercion/default/: board_options.h joint_settings_tuning.h
  group app/platform/XMC4800-F144
    ../../source/platform/XMC4800-F144+DAVE/: main.cpp zppm-periphery.cpp zppm-periphery-dev.c robosd_app_tuning.hpp
  group robosd++/mexo
    ../../../../reference/robosdpp-ref/mexo/: mexo.cpp mexo.hpp ps.cpp ps.hpp
  group robosd++/core
    ../../../../reference/robosdpp-ref/core/: robosd_system.cpp robosd_system.hpp robosd_string.cpp robosd_string.hpp
software components: CMSIS:CORE 5.4.0, Device:Startup 2.2.4, Device:XMClib:CAN 2.1.24, Device:XMClib:CCU4 2.1.24, Device:XMClib:CCU8 2.1.24, Device:XMClib:DAC 2.1.24, Device:XMClib:DMA 2.1.24, Device:XMClib:DSD 2.1.24, Device:XMClib:EBU 2.1.24, Device:XMClib:ERU 2.1.24, Device:XMClib:ETH_MAC 2.1.24, Device:XMClib:FCE 2.1.24, Device:XMClib:FLASH 2.1.24, Device:XMClib:GPIO 2.1.24, Device:XMClib:HRPWM 2.1.24, Device:XMClib:I2C 2.1.24, Device:XMClib:I2S 2.1.24, Device:XMClib:LEDTS 2.1.24, Device:XMClib:POSIF 2.1.24, Device:XMClib:RTC 2.1.24, Device:XMClib:SCU 2.1.24, Device:XMClib:SDMMC 2.1.24, Device:XMClib:SPI 2.1.24, Device:XMClib:UART 2.1.24, Device:XMClib:USB 2.1.24, Device:XMClib:VADC 2.1.24, Device:XMClib:WDT 2.1.24
